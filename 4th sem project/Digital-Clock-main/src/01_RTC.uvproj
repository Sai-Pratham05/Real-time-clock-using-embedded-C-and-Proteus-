# Keil uVision project 01_RTC.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 01_RTC +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 conf.h constants.h i2c.h lcd.h main.h port.h i2c.c lcd.c main.c uart.c uart.h
